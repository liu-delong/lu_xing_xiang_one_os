# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APOLLO512-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO RT_USING_ARM_LIBC keil
  c include: .;appplication;board;..\..\kernel\include;..\..\kernel\include\extend;..\..\common\ring_buff\include;..\..\common\ring_blk_buff\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\components\shell\include;..\..\components\atest\include;..\..\kernel\source;..\..\drivers;..\..\drivers\hal\apollo\apollo\drivers;..\..\drivers\hal\apollo\apollo\drivers\hal;..\..\drivers\hal\apollo\apollo\drivers\regs;..\..\drivers\hal\apollo\hal_drivers;..\..\libc\include\armlibc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
