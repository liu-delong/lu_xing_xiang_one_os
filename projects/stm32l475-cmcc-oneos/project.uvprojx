# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_USING_ARM_LIBC, USE_HAL_DRIVER, STM32L475xx
  c include: cmiot_pkgs\micropython;.;application;..\..\drivers\audio;board;board\CubeMX_Config\Inc;board\ports;..\..\common\include;..\..\components\diagnose\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\can;..\..\drivers\fal;..\..\drivers\hwcrypto;.;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\spi\sfud\inc;..\..\drivers\timer;..\..\drivers\usb\usbdevice;..\..\drivers\watchdog;..\..\drivers\pin;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\components\fs\include\fatfs;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Include;..\..\drivers\infrared;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\thirdparty\MicroPython\kernel;..\..\thirdparty\MicroPython\user;..\..\thirdparty\MicroPython\user\start\include;..\..\thirdparty\MicroPython\user\machine;..\..\thirdparty\MicroPython\user\machine\middle\Include;..\..\thirdparty\MicroPython\user\machine\driver\OneOS\Include;..\..\thirdparty\MicroPython\user\machine\device_bus_model;..\..\thirdparty\MicroPython\user\components\Include;..\..\thirdparty\MicroPython\user\components\module;..\..\components\net\molink\core\include;..\..\components\net\molink\api\include;..\..\components\net\molink\parser\include;..\..\components\net\molink\module\esp8266\include;..\..\thirdparty\mpu6xxx\inc;cmiot_pkgs\Device\audio;cmiot_pkgs\Device\beep;cmiot_pkgs\Device\humiture;cmiot_pkgs\Device\key;cmiot_pkgs\Device\lcd;cmiot_pkgs\Device\led;cmiot_pkgs\Device\lightsensor;cmiot_pkgs\Device\six_axis;cmiot_pkgs\Device;.;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\net\tools\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
    ../../drivers/driver_test/: sensor_acce_test.c
  group audio
    ../../drivers/audio/: audio_player.c audio_recorder.c audio_pipe.c sai.c es8388.c es8388_ll.c
  group bsp
    board/: board.c power_control.c
    board/CubeMX_Config/Src/: bsp.c stm32l4xx_it.c stm32l4xx_hal_msp.c system_stm32l4xx.c
    board/startup/: startup_stm32l475xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/cortex-m4/: cpuport.c context_rvds.S
  group drivers
    ../../drivers/: drivers.c
    ../../drivers/bus/: bus.c
    ../../drivers/can/: can.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/hwcrypto/: hwcrypto.c hw_rng.c hw_crc.c
    ../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/misc/: push_button.c adc.c dac.c pwm.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_msd.c spi_tfcard.c spi_flash_sfud.c
    ../../drivers/spi/flash/: flash_qspi.c fal_flash_sfud_port.c
    ../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../drivers/usb/usbdevice/class/: hid.c
    ../../drivers/watchdog/: watchdog.c
  group drivers/pin
    ../../drivers/pin/: pin.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
    ../../components/fs/source/fatfs/: diskio.c ff.c syscall.c unicode.c vfs_fatfs.c
  group graphic
    ../../drivers/graphic/: graphic.c st7789vw.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_spi.c drv_qspi.c drv_dac.c drv_can.c drv_rtc.c drv_crypto_rng.c drv_crypto_crc.c drv_iwdg.c drv_usbd.c drv_sai.c drv_common.c
    ../../drivers/hal/st/drivers/drv_flash/: drv_flash_l4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_hcd.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_can.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_clock.c os_device.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group micropython
    ../../thirdparty/MicroPython/kernel/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c emitnxtensawin.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpz.c nativeglue.c nlr.c nlrpowerpc.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c profile.c pystack.c qstr.c reader.c repl.c ringbuf.c runtime.c runtime_utils.c scheduler.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    ../../thirdparty/MicroPython/kernel/lib/mp-readline/: readline.c
    ../../thirdparty/MicroPython/kernel/lib/utils/: interrupt_char.c mpirq.c printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c
    ../../thirdparty/MicroPython/kernel/lib/netutils/: dhcpserver.c netutils.c trace.c
    ../../thirdparty/MicroPython/kernel/lib/timeutils/: timeutils.c
    ../../thirdparty/MicroPython/user/machine/: frozen_mpy.c modos.c modpyb.c modusocket.c modutime.c softqspi.c softspi.c virtpin.c
    ../../thirdparty/MicroPython/user/machine/middle/: machine_adc.c machine_can.c machine_dac.c machine_dump_addr.c machine_file.c machine_hw_i2c.c machine_hw_spi.c machine_i2c.c machine_lowpower.c machine_mem.c machine_pin.c machine_pinbase.c machine_pm.c machine_pulse.c machine_pwm.c machine_rtc.c machine_signal.c machine_spi.c machine_timer.c machine_uart.c machine_wdt.c
    ../../thirdparty/MicroPython/user/start/src/: mpy_main.c
    ../../thirdparty/MicroPython/user/machine/driver/OneOS/: usr_adc.c usr_can.c usr_dac.c usr_file.c usr_gccollect.c usr_i2c.c usr_lpower.c usr_misc.c usr_pin.c usr_pm.c usr_pwm.c usr_rtc.c usr_spi.c usr_stdio.c usr_thread.c usr_timer.c usr_uart.c usr_wdt.c
    ../../thirdparty/MicroPython/user/machine/device_bus_model/: model_device.c
    ../../thirdparty/MicroPython/user/components/module/: modubinascii.c moduhashlib.c moduheapq.c modujson.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c mpthreadport.c utime_mphal.c
  group molink
    ../../components/net/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_netserv.c mo_netconn.c mo_wifi.c
    ../../components/net/molink/parser/source/: at_parser.c at_resp.c
    ../../components/net/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_wifi.c esp8266_netserv.c esp8266_netconn.c
  group mpu6xxx
    ../../thirdparty/mpu6xxx/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group mpy_device
    cmiot_pkgs/Device/audio/: device_audio.c usr_audio.c
    cmiot_pkgs/Device/beep/: device_beep.c usr_beep.c
    cmiot_pkgs/Device/humiture/: device_humiture.c usr_humiture.c
    cmiot_pkgs/Device/key/: device_key.c usr_key.c
    cmiot_pkgs/Device/lcd/: device_lcd.c usr_lcd.c
    cmiot_pkgs/Device/led/: device_led.c usr_led.c
    cmiot_pkgs/Device/lightsensor/: device_lightsensor.c usr_lightsensor_ap3216.c
    cmiot_pkgs/Device/six_axis/: device_six_axis.c usr_six_axis.c
    cmiot_pkgs/Device/: moddevice.c
  group sensors
    ../../drivers/sensors/: sensor.c aht10.c mpu6xxx_port.c ap3216c.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group tools
    ../../components/net/tools/source/: tool.c
