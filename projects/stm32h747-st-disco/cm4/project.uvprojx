# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4, STM32H747xx, USE_HAL_DRIVER, OS_USING_ARM_LIBC
  c include: .;application;..\..\..\components\atest\include;board;..\common\CubeMX_Config\CM4\Inc;board\ports;..\..\..\common\include;..\..\..\arch\arm\common;..\..\..\arch\arm\cortex-m4;..\..\..\components\diagnose\include;..\..\..\components\dlog\include;..\..\..\drivers;..\..\..\drivers\bus;..\..\..\drivers\dma;..\..\..\drivers\fal;..\..\..\drivers\i2c;..\..\..\drivers\misc;..\..\..\drivers\pin;..\..\..\drivers\rtc;..\..\..\drivers\serial;..\..\..\drivers\spi;..\..\..\drivers\timer;..\..\..\drivers\watchdog;..\..\..\components\fs\include;..\..\..\components\fs\include\devfs;..\..\..\drivers\hal\st\devices;..\..\..\drivers\hal\st\drivers;..\..\..\drivers\hal\st\drivers\config;..\..\..\drivers\hal\st\drivers\drv_flash;..\..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Include;..\..\..\kernel\include;..\..\..\kernel\include\extend;..\..\..\libc\include;..\..\..\libc\include\armlibc;..\..\..\components\shell\include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group atest
    ../../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    ../common/CubeMX_Config/CM4/Src/: bsp.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../common/CubeMX_Config/Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
    board/startup/: startup_stm32h747xx_arm.s
  group common
    ../../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../../arch/arm/common/: cortexm_common.c
    ../../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../../components/dlog/source/: dlog.c
    ../../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../../drivers/: os_drivers.c os_device.c
    ../../../drivers/bus/: bus.c
    ../../../drivers/dma/: os_dma.c
    ../../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../../drivers/i2c/: i2c.c
    ../../../drivers/misc/: push_button.c adc.c
    ../../../drivers/pin/: pin.c
    ../../../drivers/rtc/: rtc.c
    ../../../drivers/serial/: serial.c
    ../../../drivers/spi/: spi_core.c spi_dev.c qspi_core.c
    ../../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../../components/fs/source/devfs/: vfs_devfs.c
  group hal/devices
    ../../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_qspi.c drv_adc.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../../drivers/hal/st/drivers/drv_flash/: drv_flash_h7.c
  group hal/lowlevel
    ../../../drivers/hal/st/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_tim.c stm32h7xx_ll_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_spdifrx.c
  group kernel
    ../../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../../libc/source/common/: gmtime_r.c
  group shell
    ../../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
