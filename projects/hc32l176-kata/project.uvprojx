# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L176KATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: oneos
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, OS_USING_ARM_LIBC, SOC_SERIES_HC32L1_XXX
  c include: .;application;board;board\ports;..\..\drivers\hal\hc\hal_drivers;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m0;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\hal\hc\HC32L17x_HAL\inc;..\..\drivers\hal\hc\HC32L17x_HAL\common;..\..\drivers\hal\hc\CMSIS\Core\Include;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*Handler --diag_suppress L6314W
  group application
    application/: main.c
  group bsp
    board/: board.c
    board/startup/: startup_hc32l17x_arm.s
    ../../drivers/hal/hc/hal_drivers/: drv_common.c drv_gpio.c drv_usart_l1xx.c
    ../../drivers/hal/hc/hal_drivers/flash/: drv_flash_l1xx.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m0/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
  group hal
    ../../drivers/hal/hc/HC32L17x_HAL/src/: hc_sysctrl.c hc_ddl.c hc_gpio.c hc_reset.c hc_lpuart.c hc_uart.c hc_flash.c
    ../../drivers/hal/hc/HC32L17x_HAL/common/: interrupts_hc32l17x.c system_hc32l17x.c
  group kernel
    ../../kernel/source/: os_clock.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mem_small.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_dataqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
