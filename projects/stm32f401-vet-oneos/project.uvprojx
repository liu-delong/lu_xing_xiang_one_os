# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F401VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_USING_ARM_LIBC, STM32F401xE, USE_HAL_DRIVER
  c include: .;application;board;board\CubeMX_Config\Core\Inc;board\ports;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m4;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\spi\sfud\inc;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\components\fs\include\fatfs;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\drivers\hal\st\STM32F4xx_HAL\CMSIS\Include;..\..\drivers\infrared;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\net\molink\core\include;..\..\components\net\molink\api\include;..\..\components\net\molink\parser\include;..\..\components\net\molink\module\esp8266\include;..\..\thirdparty\mpu6xxx\inc;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\net\tools\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group bsp
    board/: board.c power_control.c
    board/CubeMX_Config/Core/Src/: bsp.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    board/startup/: startup_stm32f401xe_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_tfcard.c spi_flash_sfud.c
    ../../drivers/spi/flash/: fal_flash_sfud_port.c flash_spi.c
    ../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
    ../../components/fs/source/fatfs/: diskio.c ff.c syscall.c unicode.c vfs_fatfs.c
  group graphic
    ../../drivers/graphic/: graphic.c st7789vw.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_i2c.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../drivers/hal/st/drivers/drv_flash/: drv_flash_f4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group molink
    ../../components/net/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_ping.c mo_ifconfig.c mo_netconn.c mo_wifi.c
    ../../components/net/molink/parser/source/: at_parser.c at_resp.c
    ../../components/net/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_wifi.c esp8266_ping.c esp8266_ifconfig.c esp8266_netconn.c
  group mpu6xxx
    ../../thirdparty/mpu6xxx/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group sensors
    ../../drivers/sensors/: sensor.c aht10.c mpu6xxx_port.c ap3216c.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group tools
    ../../components/net/tools/source/: tool.c
