# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None; default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_PLATFORM_8711B; __IEEE_LITTLE_ENDIAN
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: packages\sdk-amebaz-v4.0e\component\os\freertos; packages\sdk-amebaz-v4.0e\component\os\freertos\freertos_v10.0.1\Source\include; packages\sdk-amebaz-v4.0e\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_CM4F; packages\sdk-amebaz-v4.0e\component\os\os_dep\include; packages\sdk-amebaz-v4.0e\component\common\api; packages\sdk-amebaz-v4.0e\component\common\api\at_cmd; packages\sdk-amebaz-v4.0e\component\common\api\platform; packages\sdk-amebaz-v4.0e\component\common\api\wifi; packages\sdk-amebaz-v4.0e\component\common\api\wifi\rtw_wpa_supplicant\src; packages\sdk-amebaz-v4.0e\component\common\api\wifi\rtw_wowlan; packages\sdk-amebaz-v4.0e\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant; packages\sdk-amebaz-v4.0e\component\common\application; packages\sdk-amebaz-v4.0e\component\common\drivers\sdio\realtek\sdio_host\inc; packages\sdk-amebaz-v4.0e\component\common\drivers\usb_class\device; packages\sdk-amebaz-v4.0e\component\common\drivers\usb_class\device\class; packages\sdk-amebaz-v4.0e\component\common\drivers\wlan\realtek\include; packages\sdk-amebaz-v4.0e\component\common\drivers\wlan\realtek\src\osdep; packages\sdk-amebaz-v4.0e\component\common\drivers\wlan\realtek\wlan_ram_map\rom; packages\sdk-amebaz-v4.0e\component\common\network; packages\sdk-amebaz-v4.0e\component\common\network\ssl\polarssl-1.3.8\include; packages\sdk-amebaz-v4.0e\component\common\network\ssl\mbedtls-2.4.0\include; packages\sdk-amebaz-v4.0e\component\common\network\ssl\ssl_ram_map\rom; packages\sdk-amebaz-v4.0e\component\common\test; packages\sdk-amebaz-v4.0e\component\common\utilities; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\app\monitor\include; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\cmsis; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\cmsis\device; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\fwlib; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\fwlib\include; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\fwlib\ram_lib; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\swlib\std_lib\include; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\swlib\std_lib\libc\rom\string; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\swlib\rtl_lib; packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\misc; packages\sdk-amebaz-v4.0e\component\common\mbed\api; packages\sdk-amebaz-v4.0e\component\common\mbed\hal; packages\sdk-amebaz-v4.0e\component\common\mbed\hal_ext; packages\sdk-amebaz-v4.0e\component\common\mbed\targets\hal\rtl8711b; packages\sdk-amebaz-v4.0e\component\common\network\coap\include; ..\ameba; ..\..\kernel\include; ..\..\kernel\include\extend; ..\..\drivers\wlan; ..\..\drivers\serial; ..\..\drivers; ..\..\components\shell\include; ..\..\components\shell\source; ..\..\components\net\lwip\lwip-2.0.2\src\include; ..\..\components\net\lwip\lwip-2.0.2\src\include\lwip; ..\..\components\net\lwip\lwip-2.0.2\src\include\netif; ..\..\components\net\lwip\lwip-2.0.2\src; ..\..\components\net\lwip\lwip-2.0.2\src\arch\include; $PROJ_DIR$; ..\..\libc\include; ..\..\libc\include\dlib; ..\..\components\dlog\include; ..\..\components\atest\include; board; patch\os; ..\..\components\net\netdev\include; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\net\sal\include\socket; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\net\lwip_dhcpd; ..\..\components\dlog\include; ..\..\common\ring_blk_buff\include; ..\..\common\ring_buff\include; ..\..\drivers\hal\ameba\hal_drivers; packages\sdk-amebaz-v4.0e\project\realtek_amebaz_va0_example\inc; patch; ..\..\drivers\watchdog; ..\..\components\fal\inc; board\ports
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  prebuild: CSCRIPT  "packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$" "1" "0x08080000"
  postbuild: CSCRIPT  "packages\sdk-amebaz-v4.0e\component\soc\realtek\8711b\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --pi_veneers
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group ameba_sdk/console
    packages/sdk-amebaz-v4.0e/component/soc/realtek/8711b/app/monitor/ram/: rtl_consol.c
  group ameba_sdk/lib
    packages/sdk-amebaz-v4.0e/component/soc/realtek/8711b/misc/bsp/lib/common/IAR/: lib_http.a lib_mdns.a lib_p2p.a lib_platform.a lib_rtlstd.a lib_websocket.a lib_wlan.a lib_wlan_mp.a lib_wps.a lib_xmodem.a
  group ameba_sdk/network/api/wifi
    packages/sdk-amebaz-v4.0e/component/common/api/wifi/: wifi_ind.c wifi_promisc.c wifi_util.c
  group ameba_sdk/network/api/wifi/rtw_wpa_supplicant
    packages/sdk-amebaz-v4.0e/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c
  group ameba_sdk/os/osdep
    packages/sdk-amebaz-v4.0e/component/os/os_dep/: device_lock.c osdep_service.c
  group ameba_sdk/peripheral/api
    packages/sdk-amebaz-v4.0e/component/common/mbed/targets/hal/rtl8711b/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group ameba_sdk/peripheral/rtl8710b
    packages/sdk-amebaz-v4.0e/component/soc/realtek/8711b/fwlib/ram_lib/: rtl8710b_dsleepcfg.c rtl8710b_dstandbycfg.c rtl8710b_intfcfg.c rtl8710b_pinmapcfg.c rtl8710b_sleepcfg.c
    packages/sdk-amebaz-v4.0e/component/soc/realtek/8711b/misc/: rtl8710b_ota.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    ../../drivers/hal/ameba/hal_drivers/: drv_flash.c drv_rtc.c drv_uart.c drv_wdt.c drv_wifi.c drv_wlan.c
  group cmsis
    patch/realtek/8711b/: app_start.c
    board/startup/: context_iar.S
    ../../arch/arm/cortex-m4/: cpuport.c
    packages/sdk-amebaz-v4.0e/component/soc/realtek/8711b/fwlib/ram_lib/: startup.c
  group common
    ../../common/ring_blk_buff/source/: ring_blk_buff.c
    ../../common/ring_buff/source/: ring_buff.c
  group dlib
    ../../libc/source/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group dlog
    ../../components/dlog/source/backend/: console_be.c
    ../../components/dlog/source/: dlog.c
  group driver
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/watchdog/: watchdog.c
    ../../drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group driver_test
    ../../drivers/driver_test/: rtc_test.c wdt_test.c
  group fal
    ../../components/fal/src/: fal.c fal_flash.c fal_os.c fal_partition.c
  group kernel
    ../../kernel/source/: os_clock.c os_device.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_heap.c os_mem_pool.c os_mem_slab.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group lwip
    ../../components/net/lwip/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip/lwip-2.0.2/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.2/src/arch/: sys_arch.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group patch
    patch/os/: os_service.c
    patch/realtek/common/wifi/: wifi_conf.c
  group sal
    ../../components/net/sal/impl/: af_inet_lwip.c
    ../../components/net/sal/src/: sal_socket.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group user
    application/: main.c
