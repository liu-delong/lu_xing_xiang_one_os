# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.3.01
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __VTOR_PRESENT,__A04,__DEBUG
  c include: .;application;board;board\ports;..\..\kernel\include;..\..\kernel\include\extend;..\..\common\ring_blk_buff\include;..\..\common\ring_buff\include;..\..\components\atest\include;..\..\components\dlog\include;..\..\components\fal\inc;..\..\components\shell\include;..\..\drivers;..\..\drivers\misc;..\..\drivers\serial;..\..\libc\include;..\..\libc\include\armlibc;..\..\drivers\hal\fm\FM33A0xx_HAL\FM33A0xx_HAL_Driver\Inc;..\..\drivers\hal\fm\hal_drivers;..\..\drivers\hal\fm\FM33A0xx_HAL\CMSIS;.\board\startup;.\board\startup\ARM;.\board\ports
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
