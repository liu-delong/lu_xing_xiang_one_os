# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.3.01
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __VTOR_PRESENT, USE_HAL_DRIVER, OS_USING_ARM_LIBC, __DEBUG, __A04, FM33A0xx
  c include: .;application;..\..\components\atest\include;board;build\bsp;board\ports;..\..\drivers\hal\fm\hal_drivers;..\..\drivers\hal\fm\hal_drivers\config;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m0;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\hal\fm\FM33A0xx_HAL\FM33A0xx_HAL_Driver\Inc;..\..\drivers\hal\fm\FM33A0xx_HAL\CMSIS;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c wdt.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/startup/: system_FM33A0XX.c startup_FM33A0XX_arm.s
    ../../drivers/hal/fm/hal_drivers/: drv_gpio.c drv_led.c drv_spi.c drv_adc.c drv_rtc.c drv_flash.c drv_common.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m0/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/misc/: push_button.c adc.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group hal
    ../../drivers/hal/fm/FM33A0xx_HAL/FM33A0xx_HAL_Driver/Src/: fm33a0xx_aes.c fm33a0xx_anac.c fm33a0xx_btim.c fm33a0xx_crc.c fm33a0xx_dma.c fm33a0xx_etim.c fm33a0xx_gpio.c fm33a0xx_hspi.c fm33a0xx_lcd.c fm33a0xx_lptim.c fm33a0xx_pmu.c fm33a0xx_rcc.c fm33a0xx_scu.c fm33a0xx_trng.c fm33a0xx_u7816.c fm33a0xx_wwdt.c fm33a0xx_flash.c fm33a0xx_spi.c fm33a0xx_rtc.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
