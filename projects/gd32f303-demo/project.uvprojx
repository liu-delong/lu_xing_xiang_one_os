# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: OS_USING_ARM_LIBC, GD32F30X_HD, USE_STDPERIPH_DRIVER
  c include: .;application;board;board\ports;..\..\drivers\hal\gd\GD32F30x_HAL\GD32F30x_standard_peripheral\Include;..\..\drivers\hal\gd\GD32F30x_HAL\CMSIS\GD\GD32F30x\Include;board\CubeMX_Config\Inc;..\..\drivers\hal\gd\GD32F30x_HAL\CMSIS;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m4;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers\driver_test;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\drivers\hal\gd\devices;..\..\drivers\hal\gd\drivers;..\..\drivers\hal\gd\drivers\config;..\..\drivers\hal\gd\GD32F30x_HAL\GD32F30x_standard_peripheral\Include;..\..\drivers\hal\gd\GD32F30x_HAL\CMSIS\GD\GD32F30x\Include;..\..\drivers\hal\gd\GD32F30x_HAL\CMSIS;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: gd32f30x_it.c system_gd32f30x.c
    board/startup/: startup_gd32f30x_hd_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group driver_test
    ../../drivers/driver_test/: key_test.c rtc_test.c wdg_test.c clocksource_test.c clockevent_test.c hrtimer_test.c adc_test.c dac_test.c serial_test.c fal_test.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/i2c/: i2c.c at24cxx.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
  group hal/devices
    ../../drivers/hal/gd/devices/: gd_devices.c
  group hal/drivers
    ../../drivers/hal/gd/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_i2c.c drv_adc.c drv_dac.c drv_rtc.c drv_wdg.c drv_common.c
    ../../drivers/hal/gd/drivers/drv_flash/: drv_flash_f3.c
  group hal/lowlevel
    ../../drivers/hal/gd/GD32F30x_HAL/GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_misc.c gd32f30x_gpio.c gd32f30x_exti.c gd32f30x_fwdgt.c gd32f30x_usart.c gd32f30x_adc.c gd32f30x_dac.c gd32f30x_i2c.c gd32f30x_spi.c gd32f30x_fmc.c gd32f30x_rtc.c gd32f30x_bkp.c gd32f30x_pmu.c gd32f30x_timer.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
