# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_USING_ARM_LIBC, USE_HAL_DRIVER, AM_PART_APOLLO2, AM_PACKAGE_BGA, keil
  c include: .;application;..\..\components\atest\include;board;board\CubeMX_Config\Inc;board\ports;..\..\drivers\hal\apollo\hal_drivers;..\..\drivers\hal\apollo\hal_drivers\config;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m4;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\hal\apollo\apollo2\drivers;..\..\drivers\hal\apollo\apollo2\drivers\hal;..\..\drivers\hal\apollo\apollo2\drivers\regs;..\..\drivers\hal\apollo\apollo2\devices;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/startup/: startup_keil.s
    ../../drivers/hal/apollo/hal_drivers/: drv_gpio.c drv_led.c drv_uart.c drv_common.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
  group hal
    ../../drivers/hal/apollo/apollo2/drivers/hal/: am_hal_sysctrl.c am_hal_interrupt.c am_hal_itm.c am_hal_ctimer.c am_hal_clkgen.c am_hal_mcuctrl.c am_hal_rtc.c am_hal_vcomp.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_queue.c am_hal_cachectrl.c am_hal_pwrctrl.c am_hal_gpio.c am_hal_uart.c
  group hal/devices
    ../../drivers/hal/apollo/apollo2/devices/: am_devices.c bsp.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
