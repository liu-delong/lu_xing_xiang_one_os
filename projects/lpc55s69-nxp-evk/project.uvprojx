# Keil uVision project project.uvprojx, settings and files
target oneos (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.3.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: oneos.out
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: OS_USING_ARM_LIBC, USE_HAL_DRIVER, CPU_LPC55S69JBD100_cm33_core0
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;applications;board;board\board;board\ports;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m33;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\hwcrypto;.;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\hal\lpc\devices;..\..\drivers\hal\lpc\drivers;..\..\drivers\hal\lpc\drivers\config;..\..\drivers\hal\lpc\drivers\drv_flash;..\..\drivers\hal\lpc\LPC55S69;..\..\drivers\hal\lpc\LPC55S69\CMSIS\Include;..\..\drivers\hal\lpc\LPC55S69\drivers;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\osal\rtthread\include;..\..\components\shell\include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: ..\..\drivers\hal\lpc\LPC55S69\arm/keil_lib_power_cm33_core0.lib --remove
  group application
    applications/: main.c
    ../../drivers/driver_test/: adc_test.c fal_test.c hwcrypto_crc_test.c key_test.c rtc_test.c serial_test.c wdg_test.c
  group bsp
    board/board/: board.c clock_config.c peripherals.c pin_mux.c system_LPC55S69_cm33_core0.c
    board/startup/: startup_LPC55S69_cm33_core0_arm.lib
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m33/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/hwcrypto/: hwcrypto.c hw_crc.c
    ../../drivers/misc/: push_button.c adc.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c
    ../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../drivers/hal/lpc/devices/: nxp_devices.c
  group hal/drivers
    ../../drivers/hal/lpc/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_adc.c drv_rtc.c drv_crypto_crc.c drv_wwdt.c drv_common.c
    ../../drivers/hal/lpc/drivers/drv_flash/: drv_flash_lpc55s69.c
  group hal/lowlevel
    ../../drivers/hal/lpc/LPC55S69/drivers/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_dma.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_iap.c fsl_inputmux.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_sdif.c fsl_sysctl.c fsl_crc.c fsl_ctimer.c fsl_i2c.c fsl_i2c_dma.c fsl_lpadc.c fsl_rtc.c fsl_usart.c fsl_usart_dma.c fsl_wwdt.c
    ../../drivers/hal/lpc/LPC55S69/arm/: keil_lib_power_cm33_core0.lib
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group rtthread
    ../../osal/rtthread/source/: rt_event.c rt_hw.c rt_irq.c rt_mailbox.c rt_mem.c rt_mq.c rt_mutex.c rt_sem.c rt_thread.c rt_timer.c rt_ulog.c rt_util.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
