# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
