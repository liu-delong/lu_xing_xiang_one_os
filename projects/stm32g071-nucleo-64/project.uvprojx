# Keil uVision project project.uvprojx, settings and files
target oneos (ARM-ADS)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00009000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_USING_ARM_LIBC, STM32G071xx, USE_HAL_DRIVER
  c include: .;application;..\..\components\atest\include;board;board\CubeMX_Config\Inc;board\ports;..\..\common\include;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\pin;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32G0xx_HAL\STM32G0xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32G0xx_HAL\CMSIS\ST\STM32G0xx\Include;..\..\drivers\hal\st\STM32G0xx_HAL\CMSIS\Include;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32g0xx_it.c stm32g0xx_hal_msp.c system_stm32g0xx.c
    board/startup/: startup_stm32g071xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/cortex-m0/: cpuport.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: drivers.c
    ../../drivers/bus/: bus.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/watchdog/: watchdog.c
  group drivers/pin
    ../../drivers/pin/: pin.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_adc.c drv_dac.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../drivers/hal/st/drivers/drv_flash/: drv_flash_g0.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32G0xx_HAL/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_cec.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart_ex.c stm32g0xx_ll_usart.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_ll_spi.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_tim.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_ll_dac.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_wwdg.c
  group kernel
    ../../kernel/source/: os_clock.c os_device.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
