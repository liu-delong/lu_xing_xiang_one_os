# Keil uVision project project.uvprojx, settings and files
target oneos (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.3.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: oneos.out
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, USE_HAL_DRIVER, OS_USING_ARM_LIBC
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;applications;..\..\drivers\audio;board;board\board;board\ports;board\source;board\source\generated;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m33;..\..\components\diagnose\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\can;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\hwcrypto;.;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\spi\sfud\inc;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\components\fs\include\fatfs;..\..\drivers\graphic;..\..\components\gui;..\..\components\gui\lvgl;..\..\components\gui\lvgl\src;..\..\drivers\hal\lpc\devices;..\..\drivers\hal\lpc\drivers;..\..\drivers\hal\lpc\drivers\config;..\..\drivers\hal\lpc\drivers\drv_flash;..\..\drivers\hal\lpc\LPC55S69;..\..\drivers\hal\lpc\LPC55S69\middleware\usb\include;..\..\drivers\hal\lpc\LPC55S69\middleware\osa;..\..\drivers\hal\lpc\LPC55S69\middleware\lists;..\..\drivers\hal\lpc\LPC55S69\middleware\usb\device;..\..\drivers\hal\lpc\LPC55S69\middleware\usb\usb_device;..\..\drivers\hal\lpc\LPC55S69\CMSIS\Include;..\..\drivers\hal\lpc\LPC55S69\drivers;..\..\drivers\infrared;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\net\molink\core\include;..\..\components\net\molink\api\include;..\..\components\net\molink\parser\include;..\..\components\net\molink\module\ml302\include;..\..\components\net\molink\module\esp8266\include;..\..\thirdparty\mpu6xxx\inc;..\..\osal\rtthread\include;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\net\tools\include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: ..\..\drivers\hal\lpc\LPC55S69\arm/keil_lib_power_cm33_core0.lib --remove
  group application
    applications/: main.c
  group audio
    ../../drivers/audio/: audio_player.c audio_recorder.c audio_pipe.c i2s.c es8388.c es8388_ll.c
  group bsp
    board/board/: board.c clock_config.c peripherals.c pin_mux.c system_LPC55S69_cm33_core0.c
    board/source/generated/: usb_device_composite.c usb_device_descriptor.c
    board/startup/: startup_LPC55S69_cm33_core0_arm.lib
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m33/: cpuport.c exc.c context_rvds.S
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/can/: can.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/hwcrypto/: hwcrypto.c hw_crc.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_tfcard.c spi_flash_sfud.c
    ../../drivers/spi/flash/: fal_flash_sfud_port.c flash_spi.c
    ../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
    ../../components/fs/source/fatfs/: diskio.c ff.c syscall.c unicode.c vfs_fatfs.c
  group graphic
    ../../drivers/graphic/: graphic.c st7789vw.c
  group gui
    ../../components/gui/lvgl/: lvgl.c lvgl_console.c
    ../../components/gui/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../../components/gui/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../../components/gui/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../../components/gui/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../components/gui/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../../components/gui/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../../components/gui/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group hal/devices
    ../../drivers/hal/lpc/devices/: nxp_devices.c
  group hal/drivers
    ../../drivers/hal/lpc/drivers/: drv_gpio.c drv_usart.c drv_utick.c drv_hwtimer.c drv_spi.c drv_i2c.c drv_adc.c drv_rtc.c drv_i2s.c drv_crypto_crc.c drv_wwdt.c drv_usbd.c drv_common.c
    ../../drivers/hal/lpc/drivers/drv_flash/: drv_flash_lpc55s69.c
  group hal/lowlevel
    ../../drivers/hal/lpc/LPC55S69/drivers/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_dma.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_iap.c fsl_inputmux.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_sdif.c fsl_sysctl.c fsl_crc.c fsl_ctimer.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_lpadc.c fsl_rtc.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    ../../drivers/hal/lpc/LPC55S69/arm/: keil_lib_power_cm33_core0.lib
    ../../drivers/hal/lpc/LPC55S69/middleware/usb/device/: usb_device_dci.c usb_device_lpcip3511.c
    ../../drivers/hal/lpc/LPC55S69/middleware/osa/: fsl_os_abstraction_bm.c
    ../../drivers/hal/lpc/LPC55S69/middleware/usb/usb_device/: usb_device_class.c usb_device_ch9.c usb_device_hid.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group molink
    ../../components/net/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_netserv.c mo_ping.c mo_ifconfig.c mo_netconn.c mo_wifi.c
    ../../components/net/molink/parser/source/: at_parser.c at_resp.c
    ../../components/net/molink/module/ml302/source/: ml302.c ml302_general.c ml302_netserv.c ml302_ping.c ml302_ifconfig.c ml302_netconn.c
    ../../components/net/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_wifi.c esp8266_ping.c esp8266_ifconfig.c esp8266_netconn.c
  group mpu6xxx
    ../../thirdparty/mpu6xxx/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group rtthread
    ../../osal/rtthread/source/: rt_event.c rt_hw.c rt_irq.c rt_mailbox.c rt_mem.c rt_mq.c rt_mutex.c rt_sem.c rt_thread.c rt_timer.c rt_ulog.c rt_util.c
  group sensors
    ../../drivers/sensors/: sensor.c aht10.c mpu6xxx_port.c ap3216c.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group tools
    ../../components/net/tools/source/: tool.c
