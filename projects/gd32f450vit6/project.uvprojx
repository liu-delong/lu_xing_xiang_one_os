# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F450VI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F450, USE_STDPERIPH_DRIVER, OS_USING_ARM_LIBC
  c include: .;application;board;board\ports;..\..\drivers\hal\gd\GD32F4xx_HAL\GD32F4xx_standard_peripheral\Include;..\..\drivers\hal\gd\GD32F4xx_HAL\CMSIS\GD\GD32F4xx\Include;board\CubeMX_Config\Inc;..\..\drivers\hal\gd\GD32F4xx_HAL\CMSIS;..\..\components\net\ota\cmiot\inc;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m4;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers\driver_test;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\drivers\hal\gd\devices;..\..\drivers\hal\gd\drivers_4xx;..\..\drivers\hal\gd\drivers_4xx\config;..\..\drivers\hal\gd\GD32F4xx_HAL\GD32F4xx_standard_peripheral\Include;..\..\drivers\hal\gd\GD32F4xx_HAL\CMSIS\GD\gd32f4xx\Include;..\..\drivers\hal\gd\GD32F4xx_HAL\CMSIS;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\net\lwip\lwip-2.1.2\src;..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\components\net\lwip\lwip-2.1.2\src\port\arch\include;..\..\components\net\lwip\lwip-2.1.2\src\port;..\..\components\shell\include;..\..\components\net\socket\include;..\..\components\net\socket\include\sys_socket;..\..\components\net\socket\include\vfs_net
  memory RVCT4: ROM 0x8040000 size 0x160000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: gd32f4xx_it.c system_gd32f4xx.c
    board/startup/: startup_gd32f450_arm.s
  group cmiot
    ../../components/net/ota/cmiot/src/: cmiot_self.c cmiot_user.c
  group cmiotlib
    ../../components/net/ota/cmiot/lib/: arm_cortex-m4_cmiot_fota.lib
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group driver_test
    ../../drivers/driver_test/: wdg_test.c fal_test.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/i2c/: i2c.c at24cxx.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
  group hal/devices
    ../../drivers/hal/gd/devices/: gd_devices.c
  group hal/drivers_4xx
    ../../drivers/hal/gd/drivers_4xx/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_wdg.c drv_common.c
    ../../drivers/hal/gd/drivers_4xx/drv_flash/: drv_flash_f4.c
  group hal/lowlevel
    ../../drivers/hal/gd/GD32F4xx_HAL/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_fwdgt.c gd32f4xx_usart.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_fmc.c gd32f4xx_timer.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group lwip
    ../../components/net/lwip/lwip-2.1.2/src/port/arch/: sys_arch.c
    ../../components/net/lwip/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/lwip-2.1.2/src/port/netif/: ethernetif.c
    ../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../components/net/lwip/lwip-2.1.2/src/apps/lwiperf/: lwiperf.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group socket
    ../../components/net/socket/source/: socket.c
