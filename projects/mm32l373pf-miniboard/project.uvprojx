# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_USING_ARM_LIBC, MM32L373XXPF, USE_STDPERIPH_DRIVER
  c include: .;application;board;board\bsp;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m3;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers\driver_test;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\hal\mm32\devices;..\..\drivers\hal\mm32\drivers;..\..\drivers\hal\mm32\MM32L3xx_HAL;..\..\drivers\hal\mm32\MM32L3xx_HAL\MM32L3xx\HAL_lib\inc;..\..\drivers\hal\mm32\MM32L3xx_HAL\MM32L3xx\Include;..\..\drivers\hal\mm32\MM32L3xx_HAL\CMSIS\KEIL_CORE;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group bsp
    board/: board.c
    board/bsp/: bsp.c
    board/startup/: startup_MM32L3xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m3/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group driver_test
    ../../drivers/driver_test/: key_test.c rtc_test.c serial_test.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
  group hal/devices
    ../../drivers/hal/mm32/devices/: mm32_devices.c
  group hal/drivers
    ../../drivers/hal/mm32/drivers/: drv_gpio.c drv_usart.c drv_rtc.c drv_common.c
  group hal/lowlevel
    ../../drivers/hal/mm32/MM32L3xx_HAL/MM32L3xx/Source/: system_MM32L3xx.c
    ../../drivers/hal/mm32/MM32L3xx_HAL/: mm32_hal.c
    ../../drivers/hal/mm32/MM32L3xx_HAL/MM32L3xx/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
